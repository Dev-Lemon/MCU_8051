# Keil uVision project LedCube3x3x3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: LedCube3x3x3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c delay.c
